# Keil uVision project 17060105130_邢谨荟_gpio_单片机.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 17060105130_邢谨荟_gpio
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\cmsis\CoreSupport;..\stdlib;..\user;..\stdlib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group mdk
    ../cmsis/arm/: startup_stm32f10x_hd.s
  group user
    ../user/: main.c system_stm32f10x.c
  group stdlib
    ../stdlib/: stm32f10x_gpio.c stm32f10x_rcc.c
  group cmsis
    ../cmsis/CoreSupport/: core_cm3.c
