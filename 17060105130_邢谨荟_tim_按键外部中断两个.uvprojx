# Keil uVision project 17060105130_邢谨荟_tim_按键外部中断两个.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 17060105130_邢谨荟_exti
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\user;..\stdlib;..\cmsis\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USR
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
  group STDLIB
    ../stdlib/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group STARTLUP
    ../cmsis/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../cmsis/CoreSupport/: core_cm3.c
